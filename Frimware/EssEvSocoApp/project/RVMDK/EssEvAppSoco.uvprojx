# Keil uVision project EssEvAppSoco.uvprojx, settings and files
target EssEvApp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EssEvAppSoco +hex
  AfterMake: fromelf.exe --bin -o ./EssEvAppSoco_v1.0.0.0.bin ./obj/EssEvAppSoco.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\Application;..\..\Libraries\FWLib\inc;..\..\Application\Protocal;..\..\Application\Encryption;..\..\Application\Helix;..\..\Application\Helix\pub;..\..\Application\Helix\real
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\obj\EssEvAppMicorMax.sct
  group START
    ./: cortexm3_macro.s stm32f10x_vector.s
  group LIB
    ../../Libraries/FWLib/src/: stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_exti.c
  group App
    ../../Application/: ActionTick.c AgentTest.c Engine.c Fs.c Key.c main.c Mixer.c MixerConfig.c MotorSpeed.c OnChipAudio.c OnChipLed.c SpiFlash.c stm32f10x_it.c SystemConfig.c SystemError.c SystemHw.c SystemInfo.c Param.c MotorSpeedHal.c CalibrationMode.c
  group Protocal
    ../../Application/Protocal/: AudioFileConvert.c BleDataLayer.c DownLoader.c Authorize.c BleTransportLayer.c Mp3Convert.c BleComHw.c BleError.c Password.c
  group Decryption
    ../../Application/Encryption/: DecryDesKey.c desc.c md2c.c md4c.c md5c.c nn.c prime.c r_keygen.c r_random.c r_stdlib.c rsa.c shsc.c Tea.c
  group Helix
    ../../Application/Helix/: mp3dec.c mp3tabs.c
    ../../Application/Helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs_fixpt.c
target EssEvAppDD (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: EssEvApp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: PROTOCAL_DD
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 5.0.1
