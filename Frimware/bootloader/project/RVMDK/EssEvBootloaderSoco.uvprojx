# Keil uVision project EssEvBootloaderSoco.uvprojx, settings and files
target EssEvApp (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EssEvBootloaderSoco +hex
  AfterMake: fromelf.exe --bin -o ./EssEvBootloaderSoco.bin ./obj/EssEvBootloaderSoco.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\Application;..\..\Libraries\FWLib\inc;..\..\Application\Protocal;..\..\Application\Encryption;..\..\Application\Helix;..\..\Application\Helix\pub;..\..\Application\Helix\real;..\..\Application\Rsa
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group START
    ./: cortexm3_macro.s stm32f10x_vector.s
  group LIB
    ../../Libraries/FWLib/src/: stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_exti.c
  group Application
    ../../Application/: ActionTick.c Aes.c ApplicationRelationship.c BleComHw.c BleDataLayer.c BleError.c BleTransportLayer.c DownLoader.c FirmwareConvert.c main.c SpiFlash.c stm32f10x_it.c SystemHwConfig.c SystemInfo.c
  group Decryption
    ../../Application/Rsa/: DecryDesKey.c desc.c md2c.c md4c.c md5c.c nn.c prime.c r_keygen.c r_random.c r_stdlib.c rsa.c shsc.c
target EssEvAppDD (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EssEvApp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: PROTOCAL_DD
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 5.0.1
