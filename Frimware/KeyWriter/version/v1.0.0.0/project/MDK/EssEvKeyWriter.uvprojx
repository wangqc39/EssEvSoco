# Keil uVision project EssEvKeyWriter.uvprojx, settings and files
target EssEvKeyWriter (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EssEvKeyWriter +hex
  AfterMake: fromelf.exe --bin -o ./EssEvKeyWriter.bin ./boj/EssEvKeyWriter.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\..\project;..\..\library\inc;..\CORE;..\..\library\FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../: main.c stm32f10x_it.c
  group Core
    ./: cortexm3_macro.s stm32f10x_vector.s
  group LIB
    ../../library/FWLib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_iwdg.c
target EssOnePlus2RtrKeyWriter (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: EssOnePlus2RtrKeyWriter +hex
  AfterMake: fromelf.exe --bin -o ./EssOnePlus2RtrKeyWriter.bin ./boj/EssOnePlus2RtrKeyWriter.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX, RTR
  c include: ..\..\project;..\..\library\inc;..\CORE;..\..\library\STM32F0_FWLib\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.0.1
