# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; xDisplay_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; MAX_NUM_BLE_CONNS=1; xPOWER_SAVING; USE_CORE_SDK; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; USE_RCOSC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE$/config/build_components.opt; -f $SRC_BLE$/config/factory_config.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE$/controller/cc26xx_r2/inc; $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; ..\..\..\src/app/application; ..\..\..\src/app; $SRC_BLE$/icall/inc; $SRC_BLE$/inc; $SRC_BLE$/profiles/dev_info; $SRC_BLE$/profiles/roles; $SRC_BLE$/profiles/roles/cc26xx; $SRC_BLE$/profiles/simple_profile; $SRC_BLE$/profiles/simple_profile/cc26xx; $SRC_BLE$/target; $SRC_BLE$\common\cc26xx\rcosc; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; C:\ti\simplelink_cc2640r2_sdk_1_30_00_25\source\ti\devices\cc26x0r2\driverlib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_peripheral_cc2640r2lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0
  ILINK.IlinkOutputFile: simple_peripheral_cc2640r2lp_app.out
  ILINK.IlinkConfigDefines: CC2650=2
  ILINK.IlinkIcfFile: $SRC_BLE$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\ble_rom_releases\cc26xx_r2\Final_Release\common_r2.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_KERNEL$\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\display\lib\display.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_StackLibrary (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; xDisplay_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=1; POWER_SAVING; STACK_LIBRARY; USE_CORE_SDK; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.IExtraOptions: -f $SRC_BLE$/config/build_components.opt; -f $SRC_BLE$/config/factory_config.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE$/controller/cc26xx_r2/inc; $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; ..\..\..\src/app; $SRC_BLE$/icall/inc; $SRC_BLE$/inc; $SRC_BLE$/profiles/dev_info; $SRC_BLE$/profiles/roles; $SRC_BLE$/profiles/roles/cc26xx; $SRC_BLE$/profiles/simple_profile; $SRC_BLE$/profiles/simple_profile/cc26xx; $SRC_BLE$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE$/common/cc26xx/iar/cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl; -f ../config/lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_KERNEL$\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\display\lib\display.arm3
configuration FlashROM_StackLibrary_RCOSC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; xDisplay_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=1; POWER_SAVING; STACK_LIBRARY; USE_CORE_SDK; USE_ICALL; USE_RCOSC; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.IExtraOptions: as above
  ICCARM.CCIncludePath2: $SRC_BLE$/controller/cc26xx_r2/inc; $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; $SRC_BLE$/common/cc26xx/rcosc; ..\..\..\src/app; $SRC_BLE$/icall/inc; $SRC_BLE$/inc; $SRC_BLE$/profiles/dev_info; $SRC_BLE$/profiles/roles; $SRC_BLE$/profiles/roles/cc26xx; $SRC_BLE$/profiles/simple_profile; $SRC_BLE$/profiles/simple_profile/cc26xx; $SRC_BLE$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE$/common/cc26xx/iar/cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: as above
  ILINK.IlinkAdditionalLibs: as above
configuration FashRom_OAD_ImageB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_LCD=0; BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; xDisplay_DISABLE_ALL; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; MAX_NUM_BLE_CONNS=1; xPOWER_SAVING; USE_CORE_SDK; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; xFEATURE_OAD; FEATURE_OAD_ONCHIP; HAL_IMAGE_B; IMAGE_INVALIDATE; USE_RCOSC
  ICCARM.IExtraOptions: -f $SRC_BLE$/config/build_components.opt; -f $SRC_BLE$/config/factory_config.opt; -f ..\..\..\..\oad_target\tirtos\iar\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\..\..\..\oad_target\tirtos\iar\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE$/controller/cc26xx_r2/inc; $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; $SRC_BLE$\common\cc26xx\rcosc; ..\..\..\src/app/application; ..\..\..\src/app; $SRC_BLE$/icall/inc; $SRC_BLE$/inc; $SRC_BLE$/profiles/dev_info; $SRC_BLE$/profiles/roles; $SRC_BLE$/profiles/roles/cc26xx; $SRC_BLE$/profiles/simple_profile; $SRC_BLE$/profiles/simple_profile/cc26xx; $SRC_BLE$/profiles/oad/cc26xx; $SRC_BLE$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; C:\ti\simplelink_cc2640r2_sdk_1_30_00_25\source\ti\devices\cc26x0r2\driverlib
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: XM_390B.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs  NO_ROM=1,OAD_IMG_B=1
  postbuild: "$TOOLS_BLE$\oad\oad_image_tool.exe" "FashRom_OAD_ImageB\Exe\XM_390B.hex" -t onchip -i app --imgVer 0 --usrId BBBB -ob "FashRom_OAD_ImageB\Exe\XM_390B_oad.bin" -m 0x7000 --r 0x7000
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ONLY_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE$/common/cc26xx/iar/cc26xx_app_oad.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\..\..\..\oad_target\tirtos\iar\config\iar_boundary.xcl
  group Application
    ../../../src/app/Application/: LAUNCHIOT_CC2640R2MOD_RGZ.c simple_peripheral.c Uart.c util.c
  group Drivers/ECC
    ../../../src/app/Drivers/ECC/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    ../../../src/app/Drivers/TRNG/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    ../../../src/app/ICall/: heapmgr.h icall.c icall.h icall_addrs.h icall_cc2650.c icall_platform.h icall_user_config.c
  group ICallBLE
    ../../../src/app/ICallBLE/: ble_user_config.c ble_user_config.h icall_api_lite.c icall_apimsg.h
  group Include
    ../../../src/app/Include/: gap.h gapbondmgr.h gapgattserver.h gatt.h hci.h osal_snv.h
  group Profiles
    ../../../src/app/Profiles/: devinfoservice.c devinfoservice.h gatt_profile_uuid.h gatt_uuid.c gatt_uuid.h gattservapp_util.c oad.c oad.h oad_reset_service.c oad_target.h peripheral.c peripheral.h simple_gatt_profile.c simple_gatt_profile.h
    $SRC_BLE$/profiles/oad/cc26xx/: oad_target_internal_flash.c
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    $SRC_BLE$/target/: board.c
    ../config/: ccfg_app_ble.c
    $SRC_BLE$/common/cc26xx/rcosc/: ccfg_app_ble_rcosc.c
    ../../../src/app/Startup/: main.c rcosc_calibration.c rcosc_calibration.h
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
