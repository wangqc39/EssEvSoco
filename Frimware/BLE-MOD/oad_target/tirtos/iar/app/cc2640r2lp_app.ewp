# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DEVICE_FAMILY=cc26x0r2; Display_DISABLE_ALL; FEATURE_OAD; FEATURE_OAD_ONCHIP; HAL_IMAGE_A; HEAPMGR_SIZE=0; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; MAX_NUM_BLE_CONNS=1; xPOWER_SAVING; USE_CORE_SDK; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; USE_RCOSC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE$/config/build_components.opt; -f $SRC_BLE$/config/factory_config.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE$/controller/cc26xx_r2/inc; $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; ..\..\..\src/app; $SRC_BLE$/icall/inc; $SRC_BLE$/inc; $SRC_BLE$/profiles/oad/cc26xx; $SRC_BLE$/profiles/roles; $SRC_BLE$/profiles/roles/cc26xx; $SRC_BLE$/target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$; $SRC_BLE$\common\cc26xx\rcosc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: oad_target_cc2640r2lp_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0,OAD_IMG_A=1
  postbuild: "$TOOLS_BLE$\oad\oad_image_tool.exe" "FlashROM\Exe\oad_target_cc2640r2lp_app.hex" "..\stack\FlashROM\Exe\oad_target_cc2640r2lp_stack.hex" "..\..\..\..\bim_oad_onchip\tirtos\iar\app\FlashOnly\Exe\bim_oad_onchip_cc2640r2lp_bim.hex" -t onchip -i production -v 0 --usrId AAAA  -ob "FlashROM\Exe\oad_target_cc2640r2lp_app_oad_onchip_production.bin" -m 0x0000 -r 0x0000
  ILINK.IlinkOutputFile: oad_target_cc2640r2lp_app.out
  ILINK.IlinkConfigDefines: CC2650=2; RTOS_ROM=1
  ILINK.IlinkIcfFile: $SRC_BLE$/common/cc26xx/iar/cc26xx_app_oad.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\ble_rom_releases\cc26xx_r2\Final_Release\common_r2.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib; $TI_RTOS_KERNEL$\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\lib\drivers_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $TI_RTOS_DRIVERS_BASE$\ti\display\lib\display.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../src/app/Application/: oad_target_app.c oad_target_app.h util.c util.h
  group Drivers/ECC
    ../../../src/app/Drivers/ECC/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    ../../../src/app/Drivers/TRNG/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    ../../../../../../../../source/ti/blestack/heapmgr/: heapmgr.h
    ../../../src/app/ICallBLE/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    ../../../../../../../../source/ti/blestack/icall/src/inc/: icall.h
    ../../../../../../../../source/ti/blestack/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../src/app/ICallBLE/: ble_user_config.c icall_api_lite.c
    ../../../../../../../../source/ti/blestack/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    ../../../../../../../../source/ti/blestack/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../../../../source/ti/blestack/profiles/roles/: gapbondmgr.h
    ../../../../../../../../source/ti/blestack/osal/src/inc/: osal_snv.h
  group Profiles
    ../../../../../../../../source/ti/blestack/inc/: gatt_profile_uuid.h gatt_uuid.h
    ../../../src/app/Profiles/: gatt_uuid.c gattservapp_util.c oad.c oad.h oad_target_internal_flash.c peripheral.c peripheral.h
    ../../../../../../../../source/ti/blestack/profiles/oad/cc26xx/: oad_target.h
  group Startup
    ../../../src/app/Application/: board.c main.c
    $SRC_BLE$/common/cc26xx/rcosc/: rcosc_calibration.c rcosc_calibration.h
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    ../../../../../../../../source/ti/blestack/common/cc26xx/iar/: cc26xx_app_oad.icf
