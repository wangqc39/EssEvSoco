# IAR project cc2640r2lp_bim.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOOT_LOADER; FEATURE_FIXED_IMAGE; FEATURE_OAD; ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $SRC_BLE$/inc; $SRC_BLE$/common/cc26xx; $SRC_BLE$/profiles/oad/cc26xx; $SRC_BLE$/bim_oad_onchip/cc26xx; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target; $SRC_COMMON$/osal/src/inc; $CC26XXWARE$; $CC26XXWARE$/driverlib; $CC26XXWARE$/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bim_oad_onchip_cc2640r2lp_bim.hex
  ILINK.IlinkOutputFile: bim_oad_onchip_cc2640r2lp_bim.out
  ILINK.IlinkConfigDefines: CC2650=2; RTOS_IN_ROM=1
  ILINK.IlinkIcfFile: $SRC_BLE$/common/cc26xx/iar/cc26xx_bim_r2.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashOnly_oad_target_debug (ARM, debug)
  as the first configuration, except:
  group Application
    ../../../src/: bim_main.c ccfg_app_ble.c ccfg_app_ble_rcosc.c oad_target_internal_flash.c startup_iar.c
    ../../../../../../../../source/ti/blestack/profiles/oad/cc26xx/: oad.h oad_target.h oad_target_external_flash.c
  group TOOLS
    ../../../../../../../../source/ti/blestack/common/cc26xx/iar/: cc26xx_bim_r2.icf
